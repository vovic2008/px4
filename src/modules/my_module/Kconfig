## src/modules/my_module/Kconfig
```kconfig
menuconfig MODULES_MY_MODULE
	bool "my_module"
	default n
	---help---
		Enable My app
```
